# IAR project eth.ewp, settings and files
configuration MB039 (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MM3U1; __MM32_MB039; __MDM2803_N; __FM24C02; __WIDESCREEN; CLOCK=8000000
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc; ..\..\app\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: MM3U1
  OBJCOPY.OOCOutputFile: eth.srec
  ILINK.IlinkOutputFile: uid.out
  ILINK.IlinkIcfFile: eth.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../app/: i2c.c main.c uart.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_beep.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_eth.c bsp_fatFS.c bsp_i2c.c bsp_key.c bsp_lcd.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_phy8720.c bsp_sdio.c bsp_spi.c bsp_tim.c bsp_uart.c
  group lib
    ../../lib/HAL_lib/: common.c HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c hal_eth.c HAL_exti.c HAL_flash.c hal_fsmc.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c hal_sdio.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../lib/startup/: mm32_startup.c mm32_system.c
